options:
  parameters:
    generate_options: qt_gui
    id: graph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '15'
    freq0: 1961E6
    gain0: '15'
    gain_mode0: 'False'
    if_gain0: '15'
    sample_rate: 3E6
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 2.4E9
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
