options:
  parameters:
    generate_options: qt_gui
    id: waterfall
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '3.7E-3'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '293883'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.5'
    max_gain: '4000'
    rate: '10e-3'
    reference: '0.5'
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '16'
    type: byte
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: alpha
    gain_omega: (alpha/2)**2
    mu: '0.5'
    omega: '4.25339'
    omega_relative_limit: '5E-3'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0199'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: symbol_rate * 2
    decim: '2'
    gain: '1'
    interp: '1'
    samp_rate: 2.5E6
    type: interp_fir_filter_ccf
    width: 50E3
    win: window.WIN_KAISER
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '5000'
    type: byte
    vlen: '16'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '15'
    freq0: 1961E6
    gain0: '15'
    gain_mode0: 'False'
    if_gain0: '15'
    sample_rate: 3E6
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '18'
    interp: '15'
    type: ccf
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '1'
    interp: '1'
    ntaps: '361'
    samp_rate: 1.25E6
    sym_rate: '293883'
    type: interp_fir_filter_ccf
  states: {}

connections:
- [analog_agc_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_complex_to_real_0, '0', blocks_float_to_char_0, '0']
- [blocks_float_to_char_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', network_tcp_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
